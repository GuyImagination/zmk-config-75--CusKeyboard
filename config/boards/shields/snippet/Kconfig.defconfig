## config/boards/shields/snippet/Kconfig.defconfig
```kconfig
if SHIELD_SNIPPET

config ZMK_KEYBOARD_NAME
    default "snippet"

config SPI
    default y
    
endif
```
